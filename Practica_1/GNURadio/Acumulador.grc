options:
  parameters:
    author: com2_A1_G1
    generate_options: qt_gui
    id: Acumulador
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__ ( self ) : # only default arguments here
              gr. sync_block . __init__ (
                  self ,
                  name ='Acumulador', # will show up in GRC
                  in_sig =[ np. float32 ],
                  out_sig =[ np. float32 ]
                  )
          def work (self , input_items , output_items ):
              x = input_items [0] # Senial de entrada .
              y0 = output_items [0] # Senial acumulada
              y0 [:] = np. cumsum (x)
              return len (y0)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    name: Acomulacion
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '16384'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-2'
  states: {}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
